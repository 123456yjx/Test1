# Keil uVision project Ennfu-F103.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User;..\..\User\led;..\..\User\delay;..\..\User\usart;..\..\User\printf;..\..\User\task;..\..\User\gpio;..\..\User\st7565;..\..\User\key;..\..\User\menu;..\..\User\application;..\..\User\timer;..\..\User\crc;..\..\User\iwdg;..\..\User\ht1622
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c board.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/crc/: bsp_crc16.c
  group BSP
    ../../User/application/: bsp_application.c
    ../../User/delay/: bsp_delay.c
    ../../User/usart/: bsp_usart.c
    ../../User/printf/: bsp_printf.c
    ../../User/gpio/: bsp_gpio.c
    ../../User/st7565/: bsp_st7565.c
    ../../User/key/: bsp_key.c
    ../../User/timer/: bsp_timer.c
    ../../User/menu/: bsp_menulayout.c
    ../../User/iwdg/: bsp_iwdg.c
    ../../User/ht1622/: bsp_ht1622.c
  group TASK
    ../../User/task/: stask.c stick.c stimer.c
  group DOC
    ../../Doc/: readme.txt
